<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Rescue_firmware_2019.ewp</path>
  </project>
  <batchBuild />
</workspace>
